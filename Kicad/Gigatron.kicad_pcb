# Repository flypie/Gigatron (continued)

## KiCad design Kicad/Gigatron.kicad_pcb (continued)

Parts:
U27, U31, U37: 74HCT377; DIP-20_W7.62mm
U28: 74HCT244; DIP-20_W7.62mm
U29, U30: 74HCT161; DIP-16_W7.62mm

Connections:
AC0: U27.9 (Q3), U28.2 (I0a); also elsewhere on the board
AC1: U27.6 (Q2), U28.4 (I1a); also elsewhere on the board
AC2: U27.5 (Q1), U28.6 (I2a); also elsewhere on the board
AC3: U27.2 (Q0), U28.8 (I3a); also elsewhere on the board
AC4: U27.15 (Q5), U28.17 (I3b); also elsewhere on the board
AC5: U27.12 (Q4), U28.15 (I2b); also elsewhere on the board
AC6: U27.19 (Q7), U28.13 (I1b); also elsewhere on the board
AC7: U27.16 (Q6), U28.11 (I0b); also elsewhere on the board
ALU0: U27.8 (D3), U29.3 (D0), U31.3 (D0), U37.8 (D3); also elsewhere on the board
ALU1: U27.7 (D2), U29.4 (D1), U31.4 (D1), U37.7 (D2); also elsewhere on the board
ALU2: U27.4 (D1), U29.5 (D2), U31.7 (D2), U37.4 (D1); also elsewhere on the board
ALU3: U27.3 (D0), U29.6 (D3), U31.8 (D3), U37.3 (D0); also elsewhere on the board
ALU4: U27.14 (D5), U30.3 (D0), U31.18 (D7), U37.13 (D4); also elsewhere on the board
ALU5: U27.13 (D4), U30.4 (D1), U31.17 (D6), U37.14 (D5); also elsewhere on the board
ALU6: U27.18 (D7), U30.5 (D2), U31.14 (D5), U37.17 (D6); also elsewhere on the board
ALU7: U27.17 (D6), U30.6 (D3), U31.13 (D4), U37.18 (D7); also elsewhere on the board
BUS0: U28.18 (O0a); also elsewhere on the board
BUS1: U28.16 (O1a); also elsewhere on the board
BUS2: U28.14 (O2a); also elsewhere on the board
BUS3: U28.12 (O3a); also elsewhere on the board
BUS4: U28.3 (O3b); also elsewhere on the board
BUS5: U28.5 (O2b); also elsewhere on the board
BUS6: U28.7 (O1b); also elsewhere on the board
BUS7: U28.9 (O0b); also elsewhere on the board
CLK2: U27.11 (CP), U29.2 (CP), U30.2 (CP), U31.11 (CP), U37.11 (CP); also elsewhere on the board
GND: U27.10 (GND), U28.10 (GND), U29.8 (GND), U30.8 (GND), U31.10 (GND), U37.10 (GND); also elsewhere on the board
H: U29.1 (~MR), U29.10 (CET), U30.1 (~MR); also elsewhere on the board
IX: U29.7 (CEP), U30.7 (CEP); also elsewhere on the board
unnamed: U29.15 (TC), U30.10 (CET)
OUT0: U37.9 (Q3); also elsewhere on the board
OUT1: U37.6 (Q2); also elsewhere on the board
OUT2: U37.5 (Q1); also elsewhere on the board
OUT3: U37.2 (Q0); also elsewhere on the board
OUT4: U37.12 (Q4); also elsewhere on the board
OUT5: U37.15 (Q5); also elsewhere on the board
OUT6: U37.16 (Q6); also elsewhere on the board
OUT7: U37.19 (Q7); also elsewhere on the board
VCC: U27.20 (VCC), U28.20 (VCC), U29.16 (VCC), U30.16 (VCC), U31.20 (VCC), U37.20 (VCC); also elsewhere on the board
X0: U29.14 (Q0); also elsewhere on the board
X1: U29.13 (Q1); also elsewhere on the board
X2: U29.12 (Q2); also elsewhere on the board
X3: U29.11 (Q3); also elsewhere on the board
X4: U30.14 (Q0); also elsewhere on the board
X5: U30.13 (Q1); also elsewhere on the board
X6: U30.12 (Q2); also elsewhere on the board
X7: U30.11 (Q3); also elsewhere on the board
Y0: U31.2 (Q0); also elsewhere on the board
Y1: U31.5 (Q1); also elsewhere on the board
Y2: U31.6 (Q2); also elsewhere on the board
Y3: U31.9 (Q3); also elsewhere on the board
Y4: U31.19 (Q7); also elsewhere on the board
Y5: U31.16 (Q6); also elsewhere on the board
Y6: U31.15 (Q5); also elsewhere on the board
Y7: U31.12 (Q4); also elsewhere on the board
~AE: U28.1 (OEa), U28.19 (OEb); also elsewhere on the board
~LD: U27.1 (~E); also elsewhere on the board
~OL: U37.1 (~E); also elsewhere on the board
~XL: U29.9 (~PE), U30.9 (~PE); also elsewhere on the board
~YL: U31.1 (~E); also elsewhere on the board

Notes on the sheet:
Accumulator
X register
Y register
Output register
From control unit
Bus gateway AC

Parts:
C43, C44: 0.1µ; C_Disc_D4.3mm_W1.9mm_P5.00mm
D5, D6, D7, D8: LED; LED_D3.0mm
J2: CONN-JACK-STEREO-R/A-3PIN-3.5MM; SJ13523N
J3: DB15_FEMALE_HighDensity_MountingHoles; DSUB-15-HD_Female_Horizontal_P2.29x1.98mm_EdgePinOffset3.03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
J4: DB9_MALE_MountingHoles; DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_H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
R8: 4605X-101-222LF; R_Array_SIP5
R9: R=10kohms; R_Array_SIP6
R10, R19: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11, R13, R15: 1k5; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R12, R14, R16: 750; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R17, R18: 68; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U38: 74HCT273; DIP-20_W7.62mm
U39: 74HC595; DIP-16_W7.62mm

Connections:
/PER/BLUE: J3.3, R15.1, R16.1
/PER/GREEN: J3.2, R13.1, R14.1
/PER/RED: J3.1, R11.1, R12.1
AC0: U38.8 (D3); also elsewhere on the board
AC1: U38.7 (D2); also elsewhere on the board
AC2: U38.4 (D1); also elsewhere on the board
AC3: U38.3 (D0); also elsewhere on the board
AC4: U38.13 (D4); also elsewhere on the board
AC5: U38.14 (D5); also elsewhere on the board
AC6: U38.17 (D6); also elsewhere on the board
AC7: U38.18 (D7); also elsewhere on the board
BUS0: U39.15 (QA); also elsewhere on the board
BUS1: U39.1 (QB); also elsewhere on the board
BUS2: U39.2 (QC); also elsewhere on the board
BUS3: U39.3 (QD); also elsewhere on the board
BUS4: U39.4 (QE); also elsewhere on the board
BUS5: U39.5 (QF); also elsewhere on the board
BUS6: U39.6 (QG); also elsewhere on the board
BUS7: U39.7 (QH); also elsewhere on the board
GND: C43.2, J2.1, J3.0, J3.5, J3.6, J3.7, J3.8, J3.10, J4.0 (PAD), J4.8, R8.1 (common), R9.6, R10.2, U38.10 (GND), U39.8 (GND); also elsewhere on the board
H: U38.1 (~Mr), U39.10 (~SRCLR); also elsewhere on the board
unnamed: C43.1, C44.2, R9.1
unnamed: C44.1, J2.2, J2.3, R10.1
unnamed: D5.1 (K), R8.4 (R3)
unnamed: D5.2 (A), U38.9 (Q3)
unnamed: D6.1 (K), R8.3 (R2)
unnamed: D6.2 (A), U38.6 (Q2)
unnamed: D7.1 (K), R8.2 (R1)
unnamed: D7.2 (A), U38.5 (Q1)
unnamed: D8.1 (K), R8.5 (R4)
unnamed: D8.2 (A), U38.2 (Q0)
unnamed: R9.2, U38.19 (Q7)
unnamed: R9.3, U38.16 (Q6)
unnamed: R9.4, U38.15 (Q5)
unnamed: R9.5, U38.12 (Q4)
OUT0: R11.2; also elsewhere on the board
OUT1: R12.2; also elsewhere on the board
OUT2: R13.2; also elsewhere on the board
OUT3: R14.2; also elsewhere on the board
OUT4: R15.2; also elsewhere on the board
OUT5: R16.2; also elsewhere on the board
OUT6: R17.2, U38.11 (Cp), U39.11 (SRCLK), U39.12 (RCLK); also elsewhere on the board
OUT7: R18.2; also elsewhere on the board
SER_DATA: J4.2, R19.2, U39.14 (SER)
SER_LATCH: J3.14, J4.3, R18.1
SER_PULSE: J3.13, J4.4, R17.1
VCC: J4.6, R19.1, U38.20 (VCC), U39.16 (VCC); also elsewhere on the board
~IE: U39.13 (~OE); also elsewhere on the board

Notes on the sheet:
The RGB resistor values depend on the 74xx sub-family of the OUT register: 7400/74LS: 390ohms / 820Ω 74HCT/HC: 750Ω / 1500Ω
Blinkenlights
Game controller input
DB15 connector for 64 colors analog RGB video out (VGA compatible)
DAC
Low pass
AC coupling High pass
Attenuation from 74HCT output to audio line level by two overlapping filter slopes: f_L = 160 Hz; f_H = 700 Hz
Line out
Audio
DB9 connector for a "Famiclone" game controller
3.5mm stereo audio connector for PC speakers or amplifier
Extended output

Board: 2 copper layers, 234.9 x 158.8 mm, 151 parts (0 on the bottom side), 212 nets.

File Original/Gigatron-BillOfMaterials.xlsx:

Gigatron Bill of Materials
https://gigatron.io/
Copyright © 2020 Walter Belgers
This Gigatron Bill of Materials is provided "as-is"
and licensed under CC BY-SA 4.0.
To view a copy of this license, visit
https://creativecommons.org/licenses/by-sa/4.0
 |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | TTL microcomputer
Function/module | Description | Part/value | On PCB | Per kit | Part URL (e.g.)
Clock | 47pF ceramic disc capacitor, radial | Code 47 | C1-C3 | 3 | https://www.digikey.nl/product-detail/en/vishay-bc-component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
Power | 220uF polarized radial input cap | Panasonic EEU-FC1E221 | C4 | 1 | https://nl.farnell.com/panasonic/eeu-fc1e221/cap-220-f-25v-2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
Power, Audio | 100nF ceramic disc | Code 104 | C5-C44 | 40 | https://www.digikey.nl/product-detail/en/vishay-bc-component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
Power | Zener diode 5.6V/5W | 1N5339B, DO-15 | D1 | 1 | https://nl.mouser.com/ProductDetail/Micro-Commercial-Compone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
Power, Blinkenlights | LED (red) | 1.8V, 2mA, 3.15mm | D2, D5-D8 | 5 | https://www.digikey.com/product-detail/en/everlight-electron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
Control unit | Signaling diode | 1N60P or BAT42 compatible, DO-35 | D3-D4,D9-D36 | 30 | https://nl.mouser.com/ProductDetail/Vishay-Semiconductors/BA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
Power | Multifuse 60V/0.75A/180mΩ | MF-R075-ND | F1 | 1 | https://www.digikey.nl/product-detail/en/bourns-inc/MF-R075/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
Power | Mini-USB receptacle | 54819-0519 | J1 | 1 | http://nl.farnell.com/molex/54819-0519/mini-usb-2-0-otg-type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
Audio | 3.5 mm audio jack | SJ-352{345}N | J2 | 1 | https://www.digikey.nl/product-detail/en/cui-inc/SJ1-3523N/C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
Video | 15pin D-SUB female receptacle | L77HDE15SD1CH4R | J3 | 1 | http://uk.farnell.com/amphenol/l77hde15sd1ch4r/connector-hd-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
Game controller | 9pin D-SUB male receptacle | 5747840-3 | J4 | 1 | https://www.digikey.nl/product-detail/en/te-connectivity-amp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
Clock | Feedback resistor | 1M | R1 | 1 | https://www.digikey.nl/product-detail/en/stackpole-electroni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
Clock | Damping resistor | 1k | R2 | 1 | https://www.digikey.nl/product-detail/en/stackpole-electroni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
Power, Control unit, Audio, Input | Resistor 2.2kΩ | 2.2k | R3,R6-R7,R10,R19 | 5 | https://www.digikey.nl/product-detail/en/stackpole-electroni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
Controll unit, Blinkenlights | 5-pin resistor array, 2.2kΩ | 4605X-101-222LF | R4-R5,R8 | 3 | https://nl.mouser.com/ProductDetail/Bourns/4605X-101-222LF?q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
Audio | 6-pin R2R netwerk, 10kΩ | 4606X-R2R-103LF | R9 | 1 | https://nl.mouser.com/ProductDetail/Bourns/4606X-R2R-103LF/?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
Video | DAC resistor | 1.5k | R11,R13,R15 | 3 | https://www.digikey.nl/product-detail/en/stackpole-electroni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
Video | DAC resistor | 750 | R12,R14,R16 | 3 | https://www.digikey.nl/product-detail/en/stackpole-electroni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
Video | Terminator HS/VS lines | 68 | R17-R18 | 2 | https://www.digikey.nl/product-detail/en/stackpole-electroni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
Clock | Hex inverter (74HCT) | 74HCT04 | U1 | 1 | http://eu.mouser.com/ProductDetail/Texas-Instruments/SN74HCT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
Power | Supervisory circuit. Power-on Reset | MCP100-450DI/TO | U2 | 1 | https://www.digikey.nl/products/en?keywords=MCP100-450DI
Program Counter, X register | 4-bit presettable counter '161/'163 | 74HCT161 | U3-U6,U29-U30 | 6 | https://nl.mouser.com/Search/ProductDetail.aspx?R=CD74HCT161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
Program ROM | EPROM 1Mb (64Kx16) | 27C1024, ≤150ns | U7 | 1 | https://nl.mouser.com/ProductDetail/Microchip-Technology-Atm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
IR,D,XOUT registers | 8-bit D-type register | 74HCT273 | U8-U9,U38 | 3 | https://nl.mouser.com/ProductDetail/Texas-Instruments/SN74HC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
Databus en input | Octal bus driver non-inv | 74HCT244 | U10,U28 | 2 | https://nl.mouser.com/ProductDetail/Texas-Instruments/SN74HC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
Control unit | Dual 2-to-4 decoder | 74HCT139 | U11 | 1 | https://nl.farnell.com/texas-instruments/sn74hct139n/logic-d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
Control unit, ALU | Dual 4-to-1 multiplexer | 74HCT153 | U12,U17-U24 | 9 | https://nl.mouser.com/ProductDetail/Texas-Instruments/CD74HC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
Control unit | 3-to-8 decoder | 74HCT138 | U13-U14 | 2 | https://nl.farnell.com/texas-instruments/sn74hct138n/ic-deco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
Control unit | Octal inverting buffer | 74HCT240 | U15 | 1 | https://nl.farnell.com/texas-instruments/sn74hct240n/octal-b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
Control unit | Quad 2-input OR | 74HCT32 | U16 | 1 | https://nl.mouser.com/ProductDetail/Texas-Instruments/CD74HC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
ALU | 4-bit adder | 74HCT283 | U25-U26 | 2 | https://nl.mouser.com/ProductDetail/Texas-Instruments/CD74HC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
AC, OUT and Y registers | Octal D-type flip-flops with common enable | 74HCT377 | U27,U31,U37 | 3 | https://www.digikey.nl/product-detail/en/texas-instruments/S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
Address unit | Quad 2-to-1 line data selector | 74HCT157 | U32-U35 | 4 | https://www.digikey.nl/product-detail/en/texas-instruments/S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
Data RAM | SRAM 32k x 8, 55ns | 62256 | U36 | 1 | http://nl.farnell.com/lyontek/ly62256pl-55lli/sram-256k-32kx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
Input register | 8-bit shift register with 3-state output | 74HC595 | U39 | 1 | http://eu.mouser.com/ProductDetail/Texas-Instruments/SN74HC5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
Clock | 6.25MHz/30pF crystal | MP062-E | Y1 | 1 | http://eu.mouser.com/Search/ProductDetail.aspx?R=MP062-Evirt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
Interconnect | Printed Circuit Board (PCB) | green, lead-free HASL | - | 1 | your favourite PCB manufacturer
Power | USB cable | AWG28 | - | 1 | https://nl.mouser.com/ProductDetail/562-3021055-03
Program ROM | UV protection label | 25.4mm x 10mm | - | 1 | https://uk.farnell.com/te-connectivity/12100/label-eprom-pcb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
IC sockets | IC socket | 40-pin DIP | - | 1 | https://www.digikey.nl/product-detail/en/on-shore-technology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
IC sockets | IC socket | 28-pin DIP | - | 1 | https://www.digikey.nl/product-detail/en/assmann-wsw-compone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
Game controller | Prefab gamepad, famicom clone | DB9 serial | - | 1 | https://nl.aliexpress.com/item/32819985527.html
Enclosure | Wooden casing with plexiglass |  | - | 1 | custom made, no longer available
Enclosure | Little rubber feet (bumpons) | SJ-5302 (7.9mm) | - | 8 | https://nl.mouser.com/ProductDetail/3M-Electronic-Specialty/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
Manual | Full-colour paper manual | Wire-O, plastic cover | - | 1 | local copy shop
Pluggy McPlugface | Printed Circuit Board (PCB) | green, lead-free HASL | - | 1 | your favourite PCB manufacturer
Pluggy McPlugface | PS/2 receptacle | mini-DIN 6 pins | J1 | 1 | https://nl.mouser.com/ProductDetail/Kycon/KMDGX-6S-AS?qs=%2F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
Pluggy McPlugface | 9pin D-SUB female receptacle | L77SDE09SOL2 | J2 | 1 | https://nl.mouser.com/ProductDetail/523-L77SDE09SOL2
Pluggy McPlugface | Microcontroller | ATtiny85 DIP-8 | U1 | 1 | http://www.mouser.com/ProductDetail/microchip/attiny85-20pu/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
Pluggy McPlugface | IC socket | 8-pin DIP | - | 1 | http://www.mouser.com/ProductDetail/mill-max/110-47-308-41-0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
EPROM content | https://github.com/kervinck/gigatron-rom
ATtiny content | https://github.com/kervinck/gigatron-rom/tree/master/Utils/B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
Assembly manual | https://gigatron.io/manual
Main PCB design files | https://gigatron.io/pcb
Pluggy PCB design files | https://gigatron.io/pluggy
20200623

## Commit log

2020-07-16 Update to work with mostly the default KiCAD items or items downloaded via the KiCAD Libraries too.
    2 Resistors added of 1k on the lines for TRUE and FALSE pull ups.
    Several things deleted which appeared at Graphic shapes on the PCB sometimes
    but could not be edited. this was done manually at the bottom of the PCB_KiCAD file.
    Deleted some PCB items around the order which marked the Copper limits of top and bottom. may have been tied to TRUE & FALSE.
    Changed USB socket type.
    This has been done not to change the board but to aid understanding and allow anyone who wants slightly easier access.
2020-07-17 Run FreeRouting to completion. Update PCB and Gerbers.
