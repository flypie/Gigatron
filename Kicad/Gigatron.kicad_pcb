# Repository flypie/Gigatron

File README.md:

This is a version of the files from https://gigatron.io/ altered to work on a vanilla KiCAD 5.1.6. Changes are minimal in the schematic and PCB, layout has only
been changed where puts dimensions or orientations changed as a result of symbol change.

The PCB hase been routed with FreeRouter automaticaly. https://freerouting.org/

The Omega symbol has been removed as it broke the routing software.

No Copyright is claimed and rmeinas with the orgibal creators of Gigatron.

## KiCad design Kicad/Gigatron.kicad_pcb

Notes on the sheet:
Instruction Fetch PC, ROM, IR, D
User Registers AC, X, Y, OUT
Control Unit CU
Memory and Adress Unit MAU, RAM
Arithmetic and Logic Unit ALU
Power, Clock and Reset CLK, RESET
Peripherals XOUT

Parts:
C1, C2, C3: 47p; C_Disc_D3.0mm_W2.0mm_P2.50mm
C4: 220µ; CP_Radial_D8.0mm_P3.50mm
C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42: .1µ; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1: 5.6V/5W; D_DO-15_P12.70mm_Horizontal
D2: LED; LED_D3.0mm
F1: 750mA/180mohms/60V; Fuse_Littelfuse_395Series
H1, H2, H3, H4: MountingHole; MountingHole_2.7mm_M2.5
J1: 54819-0519; USB_Micro-B_Wuerth_629105150521
R1: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R100, R101: 1K; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
U1: 74HCT04; DIP-14_W7.62mm
U2: MCP100-450DI; TO-92L_Inline_Wide
U11: 74HCT139; DIP-16_W7.62mm
U16: 74HCT32; DIP-14_W7.62mm
Y1: 6.25MHz/30pF; Crystal_HC49-U_Vertical

Connections:
/PCR/+5V: F1.2, J1.1
CLK1: U1.4, U1.5; also elsewhere on the board
CLK2: U1.8; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, D1.2 (A), J1.4, J1.5, R3.2, R101.1, U1.7 (GND), U2.3 (VSS), U11.16 (VCC), U16.14 (VCC); also elsewhere on the board
H: R100.1; also elsewhere on the board
L: R101.2; also elsewhere on the board
unnamed: C1.1, R1.2, U1.1, Y1.1
unnamed: C2.1, R2.1, Y1.2
unnamed: C3.1, U1.6, U1.9
unnamed: D2.1 (K), R3.1
unnamed: R1.1, R2.2, U1.2, U1.13
unnamed: U1.3, U1.11, U1.12
VCC: C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, D1.1 (K), F1.1, R100.2, U1.14 (VCC), U2.2 (VDD), U11.8 (GND), U16.7 (GND); also elsewhere on the board
~RST: D2.2 (A), U2.1 (~RST); also elsewhere on the board

Notes on the sheet:
Inverter (for long ɸ2)
Pierce oscillator
Buffer
Delay line
To instruction fetch and control unit PC, IR, D, ~WE~
To user registers AC, X, Y, OUT
The 47pF of C3 provides an additional CLK2-CLK1 shift of 5ns, which is required when using the original 70ns SRAM at 6.25MHz, or when overclocking in general. (It is not needed when using a 55ns SRAM module at 6.25MHz.)
Multifuse F1 helps protect the upstream power supply against faults/shorts in the computer (e.g. those caused by build errors or abuse)
To program counter PC
A decoupling (or bypass) capacitor in close proximity to every IC's power pin provides transient current when switching between logic levels.
Power OK indicator
Power
Clock
Reset
Zener diode D1 protects the circuit against reverse current and overvoltage
Optional booster

Schematic: PRG.sch, Gigatron Instruction Fetch

Parts:
U3, U4, U5, U6: 74HCT161; DIP-16_W7.62mm
U7: 27C1024; DIP-40_W15.24mm
U8, U9: 74HCT273; DIP-20_W7.62mm
U10: 74HCT244; DIP-20_W7.62mm

Connections:
/PRG/PC0: U3.14 (Q0), U7.21
/PRG/PC1: U3.13 (Q1), U7.22
/PRG/PC2: U3.12 (Q2), U7.23
/PRG/PC3: U3.11 (Q3), U7.24
/PRG/PC4: U4.14 (Q0), U7.25
/PRG/PC5: U4.13 (Q1), U7.26
/PRG/PC6: U4.12 (Q2), U7.27
/PRG/PC7: U4.11 (Q3), U7.28
/PRG/PC8: U5.14 (Q0), U7.29
/PRG/PC9: U5.13 (Q1), U7.31
/PRG/PC10: U5.12 (Q2), U7.32
/PRG/PC11: U5.11 (Q3), U7.33
/PRG/PC12: U6.14 (Q0), U7.34
/PRG/PC13: U6.13 (Q1), U7.35
/PRG/PC14: U6.12 (Q2), U7.36
/PRG/PC15: U6.11 (Q3), U7.37
BUS0: U3.3 (D0), U10.7 (2Y2); also elsewhere on the board
BUS1: U3.4 (D1), U10.9 (2Y3); also elsewhere on the board
BUS2: U3.5 (D2), U10.5 (2Y1); also elsewhere on the board
BUS3: U3.6 (D3), U10.12 (1Y3); also elsewhere on the board
BUS4: U4.3 (D0), U10.3 (2Y0); also elsewhere on the board
BUS5: U4.4 (D1), U10.14 (1Y2); also elsewhere on the board
BUS6: U4.5 (D2), U10.18 (1Y0); also elsewhere on the board
BUS7: U4.6 (D3), U10.16 (1Y1); also elsewhere on the board
CLK1: U3.2 (CP), U4.2 (CP), U5.2 (CP), U6.2 (CP), U8.11 (Cp), U9.11 (Cp); also elsewhere on the board
D0: U9.12 (Q4), U10.13 (2A2); also elsewhere on the board
D1: U9.9 (Q3), U10.11 (2A3); also elsewhere on the board
D2: U9.15 (Q5), U10.15 (2A1); also elsewhere on the board
D3: U9.6 (Q2), U10.8 (1A3); also elsewhere on the board
D4: U9.16 (Q6), U10.17 (2A0); also elsewhere on the board
D5: U9.5 (Q1), U10.6 (1A2); also elsewhere on the board
D6: U9.19 (Q7), U10.2 (1A0); also elsewhere on the board
D7: U9.2 (Q0), U10.4 (1A1); also elsewhere on the board
GND: U3.8 (GND), U4.8 (GND), U5.8 (GND), U6.8 (GND), U7.1, U7.11, U7.30, U8.10 (GND), U9.10 (GND), U10.10 (GND); also elsewhere on the board
H: U3.7 (CEP), U3.10 (CET), U4.7 (CEP), U7.39, U8.1 (~Mr), U9.1 (~Mr); also elsewhere on the board
IR0: U8.9 (Q3); also elsewhere on the board
IR1: U8.12 (Q4); also elsewhere on the board
IR2: U8.15 (Q5); also elsewhere on the board
IR3: U8.6 (Q2); also elsewhere on the board
IR4: U8.5 (Q1); also elsewhere on the board
IR5: U8.16 (Q6); also elsewhere on the board
IR6: U8.19 (Q7); also elsewhere on the board
IR7: U8.2 (Q0); also elsewhere on the board
L: U7.2, U7.20; also elsewhere on the board
unnamed: U3.15 (TC), U4.10 (CET)
unnamed: U4.15 (TC), U5.10 (CET)
unnamed: U5.15 (TC), U6.10 (CET)
unnamed: U7.3, U9.3 (D0)
unnamed: U7.4, U9.18 (D7)
unnamed: U7.5, U9.4 (D1)
unnamed: U7.6, U9.17 (D6)
unnamed: U7.7, U9.7 (D2)
unnamed: U7.8, U9.14 (D5)
unnamed: U7.9, U9.8 (D3)
unnamed: U7.10, U9.13 (D4)
unnamed: U7.12, U8.3 (D0)
unnamed: U7.13, U8.18 (D7)
unnamed: U7.14, U8.17 (D6)
unnamed: U7.15, U8.4 (D1)
unnamed: U7.16, U8.7 (D2)
unnamed: U7.17, U8.14 (D5)
unnamed: U7.18, U8.13 (D4)
unnamed: U7.19, U8.8 (D3)
VCC: U3.16 (VCC), U4.16 (VCC), U5.16 (VCC), U6.16 (VCC), U7.40, U8.20 (VCC), U9.20 (VCC), U10.20 (VCC); also elsewhere on the board
Y0: U5.3 (D0); also elsewhere on the board
Y1: U5.4 (D1); also elsewhere on the board
Y2: U5.5 (D2); also elsewhere on the board
Y3: U5.6 (D3); also elsewhere on the board
Y4: U6.3 (D0); also elsewhere on the board
Y5: U6.4 (D1); also elsewhere on the board
Y6: U6.5 (D2); also elsewhere on the board
Y7: U6.6 (D3); also elsewhere on the board
~DE: U10.1 (1OE), U10.19 (2OE); also elsewhere on the board
~PH: U5.9 (~PE), U6.9 (~PE); also elsewhere on the board
~PL: U3.9 (~PE), U4.9 (~PE), U5.7 (CEP), U6.7 (CEP); also elsewhere on the board
~RST: U3.1 (~MR), U4.1 (~MR), U5.1 (~MR), U6.1 (~MR); also elsewhere on the board

Notes on the sheet:
Data Register D
Instruction Register IR
PC 0:3
PC 8:11
PC 12:15
PC 4:7
Non-inverting tri-state buffer
To control unit
To memory address unit

Parts:
D3, D4: 1N60P; D_A-405_P7.62mm_Horizontal
D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36: 1N60P; D_A-405_P2.54mm_Vertical_KathodeUp
R4, R5: 4605X-101-222LF; R_Array_SIP5
R6, R7: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U11: 74HCT139; DIP-16_W7.62mm
U12: 74HCT153; DIP-16_W7.62mm
U13, U14: 74HCT138; DIP-16_W7.62mm
U15: 74HCT240; DIP-20_W7.62mm
U16: 74HCT32; DIP-14_W7.62mm

Connections:
/CU/INV_A_IN: D18.1 (K), D19.1 (K), D20.1 (K), U13.7 (O7), U15.15 (I2b)
/CU/INV_B_IN: U14.9 (O6), U15.4 (I1a), U16.2
/CU/INV_B_OUT: U15.16 (O1a), U16.5, U16.10
/CU/INV_C_IN: U12.7 (Za), U15.2 (I0a)
/CU/INV_C_OUT: D3.1 (K), U15.18 (O0a)
/CU/~BF: U11.12 (O0), U16.12
/CU/~J: D34.1 (K), D35.1 (K), D36.1 (K), U12.1 (Ea), U13.6 (E3), U14.7 (O7), U16.13
AC7: U12.14 (S0); also elsewhere on the board
AL: U15.9 (O0b); also elsewhere on the board
AR0: U15.12 (O3a); also elsewhere on the board
AR1: U15.7 (O1b); also elsewhere on the board
AR2: U15.14 (O2a); also elsewhere on the board
AR3: U15.3 (O3b); also elsewhere on the board
CLK1: U16.1; also elsewhere on the board
CO: U12.2 (S1); also elsewhere on the board
EH: D13.2 (A), D16.2 (A), D20.2 (A), R4.5 (R4); also elsewhere on the board
EL: D11.2 (A), D15.2 (A), D19.2 (A), R4.4 (R3); also elsewhere on the board
GND: U12.8 (GND), U13.8 (GND), U14.8 (GND), U15.10 (GND); also elsewhere on the board
H: U12.10 (I0b), U12.11 (I1b), U12.12 (I2b), U12.13 (I3b), U12.15 (Eb), U14.6 (E3); also elsewhere on the board
IR0: U11.2 (A0); also elsewhere on the board
IR1: U11.3 (A1); also elsewhere on the board
IR2: U11.13 (A1), U12.6 (I0a), U13.1 (A0); also elsewhere on the board
IR3: U11.14 (A0), U12.5 (I1a), U13.2 (A1); also elsewhere on the board
IR4: U11.15 (E), U12.4 (I2a), U13.3 (A2); also elsewhere on the board
IR5: U14.1 (A0); also elsewhere on the board
IR6: U14.2 (A1); also elsewhere on the board
IR7: D21.1 (K), U14.3 (A2); also elsewhere on the board
IX: U15.5 (O2b); also elsewhere on the board
L: U11.1 (E), U12.3 (I3a), U13.4 (E1), U13.5 (E2), U14.4 (E1), U14.5 (E2), U15.1 (OEa), U15.19 (OEb); also elsewhere on the board
unnamed: D9.1 (K), U13.15 (O0)
unnamed: D10.1 (K), D11.1 (K), U13.14 (O1)
unnamed: D9.2 (A), D10.2 (A), D12.2 (A), D14.2 (A), R4.2 (R1), U16.9
unnamed: D12.1 (K), D13.1 (K), U13.13 (O2)
unnamed: D14.1 (K), D15.1 (K), D16.1 (K), U13.12 (O3)
unnamed: D17.1 (K), U13.9 (O6)
unnamed: D17.2 (A), D18.2 (A), R4.3 (R2), U16.4
unnamed: D21.2 (A), D34.2 (A), R6.2, U15.11 (I0b)
unnamed: D22.1 (K), D23.1 (K), U14.15 (O0)
unnamed: D22.2 (A), D26.2 (A), D29.2 (A), D30.2 (A), D36.2 (A), R5.4 (R3), U15.6 (I2a)
unnamed: D23.2 (A), D24.2 (A), D27.2 (A), D31.2 (A), R5.5 (R4), U15.17 (I3b)
unnamed: D24.1 (K), U14.14 (O1)
unnamed: D25.1 (K), D26.1 (K), D27.1 (K), U14.13 (O2)
unnamed: D25.2 (A), D28.2 (A), D33.2 (A), R5.3 (R2), U15.13 (I1b)
unnamed: D28.1 (K), D29.1 (K), U14.12 (O3)
unnamed: D30.1 (K), D31.1 (K), U14.11 (O4)
unnamed: D32.1 (K), D33.1 (K), U14.10 (O5)
unnamed: D32.2 (A), D35.2 (A), R5.2 (R1), U15.8 (I3a)
VCC: R4.1 (common), R5.1 (common), R6.1, R7.2, U12.16 (VCC), U13.16 (VCC), U14.16 (VCC), U15.20 (VCC); also elsewhere on the board
~AE: U11.6 (O2); also elsewhere on the board
~DE: U11.4 (O0); also elsewhere on the board
~IE: U11.7 (O3); also elsewhere on the board
~LD: U16.8; also elsewhere on the board
~OE: U11.5 (O1); also elsewhere on the board
~OL: U16.6; also elsewhere on the board
~PH: D4.1 (K), U16.11; also elsewhere on the board
~PL: D3.2 (A), D4.2 (A), R7.1; also elsewhere on the board
~WE: U16.3; also elsewhere on the board
~XL: U13.11 (O4); also elsewhere on the board
~YL: U13.10 (O5); also elsewhere on the board

Notes on the sheet:
Bus access decoder
16-bit jump (JMP) detector
Wired AND
To RAM
Operation decoder
Mode decoder
From instruction register
Condition decoder
From AC and ALU
To BUS and RAM
To user registers
To memory address unit
To program counter
JUMP
STORE
SUB
ADD
XOR
AND
LOAD
During write, AC and OUT are blocked from being written to by U16B and U16C. This way, all 5 memory addressing modes can be used in ST instructions.
The control unit has: - 11 input signals: IR0:7, AC7, CO, CLK1 - The output comprises 19 control signals: /DE /OE /AE /IE AR0:3 AL /LD /XL /YL /OL IX EH EL /PL /PH /WE
XXX breakdown symbol into 8 inverter gates
To ALU
Buffer / Octal inverter
[Y,X++],OUT
[D],OUT
[D],Y
[D],X
[Y,X],AC
[Y,D],AC
[X],AC
[D],AC

Parts:
A15: A15; TestPoint_THTPad_D2.0mm_Drill1.0mm
U32, U33, U34, U35: 74HCT157; DIP-16_W7.62mm
U36: HM62256BLP-7; DIP-28_W15.24mm

Connections:
/RAM/A0: U34.12 (Zd), U36.10 (A0)
/RAM/A1: U34.4 (Za), U36.9 (A1)
/RAM/A2: U34.7 (Zb), U36.8 (A2)
/RAM/A3: U34.9 (Zc), U36.7 (A3)
/RAM/A4: U35.4 (Za), U36.6 (A4)
/RAM/A5: U35.7 (Zb), U36.5 (A5)
/RAM/A6: U35.9 (Zc), U36.4 (A6)
/RAM/A7: U35.12 (Zd), U36.3 (A7)
/RAM/A8: U32.4 (Za), U36.25 (A8)
/RAM/A9: U33.12 (Zd), U36.24 (A9)
/RAM/A10: U32.9 (Zc), U36.21 (A10)
/RAM/A11: U33.9 (Zc), U36.23 (A11)
/RAM/A12: U32.12 (Zd), U36.2 (A12)
/RAM/A13: U33.4 (Za), U36.26 (A13)
/RAM/A14: U33.7 (Zb), U36.1 (A14)
BUS0: U36.11 (Q0); also elsewhere on the board
BUS1: U36.12 (Q1); also elsewhere on the board
BUS2: U36.13 (Q2); also elsewhere on the board
BUS3: U36.15 (Q3); also elsewhere on the board
BUS4: U36.16 (Q4); also elsewhere on the board
BUS5: U36.17 (Q5); also elsewhere on the board
BUS6: U36.18 (Q6); also elsewhere on the board
BUS7: U36.19 (Q7); also elsewhere on the board
D0: U34.13 (I1d); also elsewhere on the board
D1: U34.3 (I1a); also elsewhere on the board
D2: U34.6 (I1b); also elsewhere on the board
D3: U34.10 (I1c); also elsewhere on the board
D4: U35.3 (I1a); also elsewhere on the board
D5: U35.6 (I1b); also elsewhere on the board
D6: U35.10 (I1c); also elsewhere on the board
D7: U35.13 (I1d); also elsewhere on the board
EH: U32.15 (E), U33.15 (E); also elsewhere on the board
EL: U34.1 (S), U35.1 (S); also elsewhere on the board
GND: U32.8 (GND), U33.8 (GND), U34.8 (GND), U35.8 (GND), U36.14 (GND); also elsewhere on the board
H: U32.3 (I1a), U32.6 (I1b), U32.10 (I1c), U32.13 (I1d), U33.3 (I1a), U33.6 (I1b), U33.10 (I1c), U33.13 (I1d); also elsewhere on the board
L: U32.1 (S), U33.1 (S), U34.15 (E), U35.15 (E), U36.20 (~CS); also elsewhere on the board
unnamed: A15.1, U32.7 (Zb)
VCC: U32.16 (VCC), U33.16 (VCC), U34.16 (VCC), U35.16 (VCC), U36.28 (VCC); also elsewhere on the board
X0: U34.14 (I0d); also elsewhere on the board
X1: U34.2 (I0a); also elsewhere on the board
X2: U34.5 (I0b); also elsewhere on the board
X3: U34.11 (I0c); also elsewhere on the board
X4: U35.2 (I0a); also elsewhere on the board
X5: U35.5 (I0b); also elsewhere on the board
X6: U35.11 (I0c); also elsewhere on the board
X7: U35.14 (I0d); also elsewhere on the board
Y0: U32.2 (I0a); also elsewhere on the board
Y1: U33.14 (I0d); also elsewhere on the board
Y2: U32.11 (I0c); also elsewhere on the board
Y3: U33.11 (I0c); also elsewhere on the board
Y4: U32.14 (I0d); also elsewhere on the board
Y5: U33.2 (I0a); also elsewhere on the board
Y6: U33.5 (I0b); also elsewhere on the board
Y7: U32.5 (I0b); also elsewhere on the board
~OE: U36.22 (~OE); also elsewhere on the board
~WE: U36.27 (~WE); also elsewhere on the board

Notes on the sheet:
The 6.25 MHz system has a clock period of 160 ns. In each clock cycle 1 RAM access and 1 ALU operation can be done sequentually. Therefore the computer needs an SRAM speed of 70ns for reliable operation. In the kit 55ns SRAM is included for additional headroom.
32kB/70ns static RAM
From control unit
EH L L H H
EL L H L H
AH YYYYYYYY YYYYYYYY 00000000 00000000
AL XXXXXXXX DDDDDDDD XXXXXXXX DDDDDDDD
Quad 2:1 MUX
Memory Address Unit
Notation [y,x] [y,$dd] [x] [$dd]

Parts:
U17, U18, U19, U20, U21, U22, U23, U24: 74HCT153; DIP-16_W7.62mm
U25, U26: 74HCT283; DIP-16_W7.62mm

Connections:
AC0: U21.14 (S0); also elsewhere on the board
AC1: U22.14 (S0); also elsewhere on the board
AC2: U23.14 (S0); also elsewhere on the board
AC3: U24.14 (S0); also elsewhere on the board
AC4: U17.2 (S1); also elsewhere on the board
AC5: U18.2 (S1); also elsewhere on the board
AC6: U19.2 (S1); also elsewhere on the board
AC7: U20.2 (S1); also elsewhere on the board
AL: U17.1 (Ea), U18.1 (Ea), U19.1 (Ea), U20.1 (Ea), U21.15 (Eb), U22.15 (Eb), U23.15 (Eb), U24.15 (Eb); also elsewhere on the board
ALU0: U26.4 (S1); also elsewhere on the board
ALU1: U26.1 (S2); also elsewhere on the board
ALU2: U26.13 (S3); also elsewhere on the board
ALU3: U26.10 (S4); also elsewhere on the board
ALU4: U25.4 (S1); also elsewhere on the board
ALU5: U25.1 (S2); also elsewhere on the board
ALU6: U25.13 (S3); also elsewhere on the board
ALU7: U25.10 (S4); also elsewhere on the board
AR0: U17.10 (I0b), U18.10 (I0b), U19.10 (I0b), U20.10 (I0b), U21.6 (I0a), U22.6 (I0a), U23.6 (I0a), U24.6 (I0a), U26.7 (C0); also elsewhere on the board
AR1: U17.12 (I2b), U18.12 (I2b), U19.12 (I2b), U20.12 (I2b), U21.5 (I1a), U22.5 (I1a), U23.5 (I1a), U24.5 (I1a); also elsewhere on the board
AR2: U17.11 (I1b), U18.11 (I1b), U19.11 (I1b), U20.11 (I1b), U21.4 (I2a), U22.4 (I2a), U23.4 (I2a), U24.4 (I2a); also elsewhere on the board
AR3: U17.13 (I3b), U18.13 (I3b), U19.13 (I3b), U20.13 (I3b), U21.3 (I3a), U22.3 (I3a), U23.3 (I3a), U24.3 (I3a); also elsewhere on the board
BUS0: U21.2 (S1); also elsewhere on the board
BUS1: U22.2 (S1); also elsewhere on the board
BUS2: U23.2 (S1); also elsewhere on the board
BUS3: U24.2 (S1); also elsewhere on the board
BUS4: U17.14 (S0); also elsewhere on the board
BUS5: U18.14 (S0); also elsewhere on the board
BUS6: U19.14 (S0); also elsewhere on the board
BUS7: U20.14 (S0); also elsewhere on the board
CO: U25.9 (C4); also elsewhere on the board
GND: U17.8 (GND), U18.8 (GND), U19.8 (GND), U20.8 (GND), U21.8 (GND), U22.8 (GND), U23.8 (GND), U24.8 (GND), U25.8 (GND), U26.8 (GND); also elsewhere on the board
H: U17.3 (I3a), U17.4 (I2a), U18.3 (I3a), U18.4 (I2a), U19.3 (I3a), U19.4 (I2a), U20.3 (I3a), U20.4 (I2a), U21.11 (I1b), U21.13 (I3b), U22.11 (I1b), U22.13 (I3b), U23.11 (I1b), U23.13 (I3b), U24.11 (I1b), U24.13 (I3b); also elsewhere on the board
L: U17.5 (I1a), U17.6 (I0a), U17.15 (Eb), U18.5 (I1a), U18.6 (I0a), U18.15 (Eb), U19.5 (I1a), U19.6 (I0a), U19.15 (Eb), U20.5 (I1a), U20.6 (I0a), U20.15 (Eb), U21.1 (Ea), U21.10 (I0b), U21.12 (I2b), U22.1 (Ea), U22.10 (I0b), U22.12 (I2b), U23.1 (Ea), U23.10 (I0b), U23.12 (I2b), U24.1 (Ea), U24.10 (I0b), U24.12 (I2b); also elsewhere on the board
unnamed: U17.7 (Za), U25.5 (A1)
unnamed: U17.9 (Zb), U25.6 (B1)
unnamed: U18.7 (Za), U25.2 (B2)
unnamed: U18.9 (Zb), U25.3 (A2)
unnamed: U19.7 (Za), U25.15 (B3)
unnamed: U19.9 (Zb), U25.14 (A3)
unnamed: U20.7 (Za), U25.12 (A4)
unnamed: U20.9 (Zb), U25.11 (B4)
unnamed: U21.7 (Za), U26.5 (A1)
unnamed: U21.9 (Zb), U26.6 (B1)
unnamed: U22.7 (Za), U26.3 (A2)
unnamed: U22.9 (Zb), U26.2 (B2)
unnamed: U23.7 (Za), U26.14 (A3)
unnamed: U23.9 (Zb), U26.15 (B3)
unnamed: U24.7 (Za), U26.12 (A4)
unnamed: U24.9 (Zb), U26.11 (B4)
unnamed: U25.7 (C0), U26.9 (C4)
VCC: U17.16 (VCC), U18.16 (VCC), U19.16 (VCC), U20.16 (VCC), U21.16 (VCC), U22.16 (VCC), U23.16 (VCC), U24.16 (VCC), U25.16 (VCC), U26.16 (VCC); also elsewhere on the board

Notes on the sheet:
To user registers
Back to control unit
From control unit
4-bit adders
Dual 4:1 multiplexers
Logic Unit 0
Logic Unit 3
Logic Unit 2
Logic Unit 1
Logic Unit 4
Logic Unit 5
Logic Unit 6
Each of the eight logic unit packages contains two 4:1 multiplexers we call L and R. R is fully programmable by the truth table hosted in the control unit (AR0:3). It performs logic functions on both accumulator (A) and bus data (B). L will either be zero or the value of the accumulator. Therefore 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
Instruction LD AND OR XOR ADD SUB ST Bcc
L 0 0 0 0 A A A 0
R B A AND B A OR B A XOR B B NOT B 0 NOT A
CIN 0 0 0 0 0 1 0 1
Result B A AND B A OR B A XOR B A + B A - B A -A
Logic Unit 7

Notices in the files:
Kicad/Gigatron.kicad_pcb:
©2017-2020
